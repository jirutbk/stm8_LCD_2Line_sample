# IAR project TestLCD.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: TestLCD.srec
  ILINK.IlinkOutputFile: TestLCD.out
configuration STM8S105 (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S105
  OBJCOPY.OOCOutputFile: TestLCD.hex
configuration STM8S103 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  ICCSTM8.CCDefines: STM8S105
  OBJCOPY.OOCOutputFile: TestLCD.hex
  group (top)
    ./: delay.c HD44780.c HD44780.h main.c stm8s_gpio.c
    ../../STM8S_StdPeriph_Lib/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c
